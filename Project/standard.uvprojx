# Keil uVision project standard.uvprojx, settings and files
target standard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: standard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\user;..\user\AHRS;..\user\DSP\Include;..\user\FreeRTOS\include;..\user\FreeRTOS\portable;..\user\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\hardware\led;..\user\hardware\delay;..\user\hardware\pid;..\user\hardware\rc;..\user\hardware\can;..\user\hardware\can_receive;..\user\hardware\sys;..\user\FreeRTOS_middleware;..\user\hardware\timer;..\user\hardware\usart;..\user\hardware\buzzer;..\user\hardware\usart8
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group freeRTOS
    ../user/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group AHRS
    ../user/AHRS/: AHRS.lib
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group main
    ../user/: main.c
  group hardware
    ../user/hardware/delay/: delay.c
    ../user/hardware/led/: led.c
    ../user/hardware/sys/: sys.c
    ../user/hardware/pid/: pid.c
    ../user/hardware/rc/: rc.c
    ../user/hardware/can/: can.c
    ../user/hardware/can_receive/: can_receive.c
    ../user/hardware/timer/: timer.c
    ../user/hardware/usart/: usart7.c
    ../user/hardware/buzzer/: buzzer.c
    ../user/hardware/usart8/: usart8.c
  group APP
    ../user/APP/ChassisTask/: ChassisTask.c
    ../user/APP/CommunicationTask/: CommunicationTask.c
    ../user/APP/GimbalTask/: GimbalTask.c
    ../user/APP/GrabTask/: GrabTask.c
    ../user/APP/LeftAndRightTask/: LeftAndRightTask.c
    ../user/APP/UpAndDownTask/: UpAndDownTask.c
    ../user/APP/MainTask/: MainTask.c
  group FreeRTOS_middleware
    ../user/FreeRTOS_middleware/: FreeRTOS_middleware.c
